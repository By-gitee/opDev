# Keil uVision project huawei_shengteng.uvproj, settings and files
target huawei_shengteng_project (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: huawei_shengteng +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,
  c include: .\CORE;.\STM32F10x_FWLib\inc;.\USER;.\USER\algo
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c algo.c motor_control.c Timer_interrupt.c VisionCommuinication.c
    ./USER/algo/: four_Forward_standardDH.c four_Forward_standardDH_data.c four_Forward_standardDH_initialize.c four_Forward_standardDH_terminate.c rt_nonfinite.c rtGetInf.c rtGetNaN.c SDH_IK_4axis.c SDH_IK_4axis_data.c SDH_IK_4axis_initialize.c SDH_IK_4axis_terminate.c
